# Keil uVision project KernelProject.uvproj, settings and files
target KernelProject (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: KernelProject +hex
  c flags: Optim=1
  c include: .\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries;.\kernel\inc;.\kernel\config;.\kernel\portable
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./: startup_stm32f40xx.s
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group PeripheralLibrary
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ./Libraries/: stm32f4xx_it.c
  group KernelSource
    ./kernel/: croutine.c event_groups.c list.c os_call.c queue.c tasks.c timers.c
  group KernelPortable
    ./kernel/portable/: port.c
  group KernelConfig
    ./kernel/config/: FreeRTOSConfig.h
  group KernelMemoryManager
    ./kernel/MemMang/: heap_3.c
  group Application
    ./: main.c
